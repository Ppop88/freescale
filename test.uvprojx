# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MK60D10
  c include: .\Libraries\drivers\K\inc;.\Libraries\drivers\K\src;.\Libraries\devices\inc;.\Libraries\devices\src;.\Libraries\startup\CoreSupport;.\Libraries\startup\DeviceSupport;.\user
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group driver
    ./Libraries/drivers/K/src/: adc.c can.c cmp.c common.c cpuidy.c crc.c dac.c dma.c enet.c flash.c flexbus.c ftm.c gpio.c i2c.c i2s.c lptmr.c nfc.c pdb.c pit.c rtc.c sd.c spi.c systick.c tsi.c uart.c vref.c wdog.c
  group user
    ./user/: main.c motor.c pid.c pid.h shiboqi.c shiboqi.h derivative.h hidef.h
  group startup
    ./Libraries/startup/DeviceSupport/: system_MK60D10.c startup_MK60D10.s
